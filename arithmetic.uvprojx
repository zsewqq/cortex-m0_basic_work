# Keil uVision project arithmetic.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.0-Beta12
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: arithmetic
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe #L --vhx --output arithmetic.hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe #L --vhx --bin --output arithmetic.bin
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.1
